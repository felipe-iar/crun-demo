# IAR project Heap.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe550
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Heap.out
  ILINK.IlinkIcfFile: arm_smallheap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../common/Heapcheck/: Heap.c
