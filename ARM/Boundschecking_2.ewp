# IAR project Boundschecking_2.ewp, settings and files
configuration CheckPointersFromNonInstrumentedCode (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: EXAMPLE_CHECK_POINTERS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Boundschecking_2.out
  ILINK.IlinkExtraOptions: --redirect __iar_ReportCheckFailed=__iar_ReportCheckFailedStdout
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DoNotCheckPointersFromNonInstrumentedCode (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCOptLevel: 2
  group (top)
    ../common/Boundschecking2/: Boundschecking_2.c readme.txt ReportCheckFailedStdout.c
    maxlib/: maxlib.a
