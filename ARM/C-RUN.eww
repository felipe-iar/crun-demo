<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Arithmetic.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\luminance.ewp</path>
    </project>
    <batchBuild />
</workspace>
